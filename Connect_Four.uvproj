# Keil uVision project Connect_Four.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: UART_Test
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..\..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_rvmdk.S UART_Test.c DisplayCommands.h GameBoard.h WinnerCheck.h
    ../../../../driverlib/rvmdk/: driverlib.lib
